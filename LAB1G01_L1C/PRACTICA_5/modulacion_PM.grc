options:
  parameters:
    author: Esteban - Sebastian
    copyright: Uis
    generate_options: qt_gui
    id: ModulacionPM
    output_language: python
    title: Modulacion PM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud de la portadora '
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud del mensaje '
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: 'Frecuencia del mensaje '
    start: 1e3
    step: '100'
    stop: 20e3
    value: 1e3
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: EnvolventecomplejaPM_0
  id: EnvolventecomplejaPM
  parameters:
    Ac: Ac
    Kp: kp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: 'Mensaje '
    label2: Portadora
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [EnvolventecomplejaPM_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventecomplejaPM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', EnvolventecomplejaPM_0, '0']

metadata:
  file_format: 1
