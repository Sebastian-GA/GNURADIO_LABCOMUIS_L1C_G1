options:
  parameters:
    author: Sebastian - Esteban
    generate_options: qt_gui
    id: ModulacionSSBSC
    output_language: python
    title: Modulacion SSB-SC
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '100e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {state: disabled}
- name: SelectorSSB
  id: variable_qtgui_chooser
  parameters:
    label: Selector de Banda
    label0: USSB
    label1: LSSB
    num_opts: '2'
    option0: '1'
    option1: '-1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora [MHz]
    start: '50'
    step: '1'
    stop: '2200'
    value: '50'
  states: {state: disabled}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Mensaje
    start: '0'
    step: 1e3
    stop: 100e3
    value: 20e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: EnvolventeComplejaSSBSC_0
  id: EnvolventeComplejaSSBSC
  parameters:
    Ac: Ac
    K: SelectorSSB
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [EnvolventeComplejaSSBSC_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaSSBSC_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeComplejaSSBSC_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaSSBSC_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
