options:
  parameters:
    author: Sebastian - Esteban
    generate_options: qt_gui
    id: modulacionAM
    output_language: python
    title: Modulacion AM
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud Portadora
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '100e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud Mensaje
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {state: disabled}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora [MHz]
    start: '50'
    step: '100e-3'
    stop: '2200'
    value: '50'
  states: {state: disabled}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Mensaje
    start: '0'
    step: 1e3
    stop: 100e3
    value: 20e3
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente ka
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: ModuladorAM_0
  id: ModuladorAM
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [ModuladorAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModuladorAM_0, '0', qtgui_time_sink_x_0, '0']
- [ModuladorAM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', ModuladorAM_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
