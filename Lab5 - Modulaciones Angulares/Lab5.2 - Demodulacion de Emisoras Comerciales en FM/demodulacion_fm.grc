options:
  parameters:
    author: Sebastian - Esteban
    generate_options: qt_gui
    id: DemoduladorFM
    output_language: python
    title: Demodulador FM
  states: {}

blocks:
- name: Ga
  id: variable_qtgui_range
  parameters:
    label: Ganancia Audio
    start: '0'
    step: '100e-3'
    stop: '3'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 88.1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: 200e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ga
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: 200e3
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10e6
    fc: fc
    fftsize: '8192'
    name: '"Whiout Demodulation"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 200e3
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    name: '"Demodulated"'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
